# Keil uVision project STM32F107.uvprojx, settings and files
target STM32F107VCT6 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F107
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_CL
  c include: ..\MainConfig;..\STM32F10x_StdPeriph_Driver\inc;..\CMSIS;..\Application;..\Drivers\CustomDriver\include;..\Middleware\FreeRTOS\include;..\Middleware\STemWin\inc;..\Middleware\STemWin\Config;..\BSP;..\Middleware\FatFs;..\Middleware\lwip-1.4.0\src\include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group MainConfig
    ../MainConfig/: main.c stm32f10x_it.c startup_stm32f107xc.s
  group Application
    ../Application/: BoardInfo_Task.c DebugMessage.c GUI_Task.c Naruto.c sdcard.c serialflash.c TEST_Task.c WIFI_Task.c
  group BSP
    ../BSP/: Bsp.c Periph_it.c Delay.c Rtc.c
  group Drivers
    ../Drivers/CustomDriver/source/: KEY_Driver.c LED_Driver.c LCD_Driver.c USART_Driver.c EEPROM_Driver.c IO_Driver.c SPI_Driver.c ADC_Driver.c
  group STM32F10x_StdPeriph_Driver
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group FreeRTOS
    ../Middleware/FreeRTOS/: tasks.c list.c queue.c
    ../Middleware/FreeRTOS/portable/: heap_2.c port.c
  group STemWin
    ../Middleware/STemWin/OS/: GUI_X_FreeRTOS.c
    ../Middleware/STemWin/Config/: GUIConf.c LCDConf_FlexColor_Template.c
    ../Middleware/STemWin/Lib/: STemWin528_CM3_OS_Keil.lib
  group FatFs
    ../Middleware/FatFs/: ff.c diskio.c
  group Lwip
    ../Middleware/lwip-1.4.0/src/netif/: ethernetif.c
